.include ../../../../tech_files/TSMC_180nm.txt

.param SUPPLY=1.8
.global gnd vdd

VDD vdd gnd SUPPLY
vinA3 A3 gnd PULSE(0 SUPPLY 320ns 1ps 1ps 320ns  640ns)
vinA2 A2 gnd PULSE(0 SUPPLY 160ns 1ps 1ps 160ns  320ns)
vinA1 A1 gnd PULSE(0 SUPPLY  80ns 1ps 1ps  80ns  160ns)
vinA0 A0 gnd PULSE(0 SUPPLY  40ns 1ps 1ps  40ns   80ns)
vinB3 B3 gnd PULSE(0 SUPPLY  20ns 1ps 1ps  20ns   40ns)
vinB2 B2 gnd PULSE(0 SUPPLY  10ns 1ps 1ps  10ns   20ns)
vinB1 B1 gnd PULSE(0 SUPPLY   5ns 1ps 1ps   5ns   10ns)
VinB0 B0 gnd PULSE(0 SUPPLY 2.5ns 1ps 1ps 2.5ns    5ns)

.option scale=0.09u

.subckt inv_cmos IN w_0_0# gnd vdd OUT
M1000 OUT IN vdd w_0_0# CMOSP w=50 l=2
+  ad=250 pd=110 as=250 ps=110
M1001 OUT IN gnd Gnd CMOSN w=20 l=2
+  ad=100 pd=50 as=100 ps=50
C0 OUT IN 0.05fF
C1 gnd IN 0.05fF
C2 vdd IN 0.02fF
C3 w_0_0# IN 0.06fF
C4 OUT gnd 0.21fF
C5 vdd OUT 0.52fF
C6 OUT w_0_0# 0.07fF
C7 vdd w_0_0# 0.07fF
C8 gnd Gnd 0.06fF
C9 OUT Gnd 0.05fF
C10 vdd Gnd 0.00fF
C11 IN Gnd 0.13fF
C12 w_0_0# Gnd 1.49fF
.ends

.subckt nand_cmos w_n6_n6# a_7_n61# Y A vdd B
M1000 a_7_n61# A gnd Gnd CMOSN w=40 l=2
+  ad=400 pd=180 as=200 ps=90
M1001 Y B a_7_n61# Gnd CMOSN w=40 l=2
+  ad=200 pd=90 as=0 ps=0
M1002 Y A vdd w_n6_n6# CMOSP w=50 l=2
+  ad=500 pd=220 as=500 ps=220
M1003 Y B vdd w_n6_n6# CMOSP w=50 l=2
+  ad=0 pd=0 as=0 ps=0
C0 vdd A 0.02fF
C1 Y A 0.05fF
C2 gnd a_7_n61# 0.45fF
C3 w_n6_n6# A 0.06fF
C4 vdd Y 1.60fF
C5 vdd w_n6_n6# 0.16fF
C6 B Y 0.24fF
C7 Y a_7_n61# 0.41fF
C8 B a_7_n61# 0.05fF
C9 Y w_n6_n6# 0.15fF
C10 B w_n6_n6# 0.06fF
C11 a_7_n61# Gnd 0.13fF
C12 gnd Gnd 0.07fF
C13 Y Gnd 0.14fF
C14 vdd Gnd 0.05fF
C15 B Gnd 0.17fF
C16 A Gnd 0.17fF
C17 w_n6_n6# Gnd 2.49fF
.ends

.subckt xor_optimized Y w_26_37# A B inv_cmos_0/vdd
Xinv_cmos_0 B w_26_37# inv_cmos_0/gnd inv_cmos_0/vdd inv_cmos_0/OUT inv_cmos
M1000 Y A inv_cmos_0/OUT Gnd CMOSN w=20 l=2
+  ad=100 pd=50 as=100 ps=50
M1001 Y A B w_26_37# CMOSP w=50 l=2
+  ad=250 pd=110 as=320 ps=110
C0 inv_cmos_0/OUT B 0.70fF
C1 w_26_37# B 0.28fF
C2 Y inv_cmos_0/OUT 0.28fF
C3 Y B 0.56fF
C4 Y w_26_37# 0.07fF
C5 B A 0.05fF
C6 w_26_37# A 0.10fF
C7 Y Gnd 0.05fF
C8 A Gnd 0.01fF
C9 inv_cmos_0/OUT Gnd 0.06fF
C10 B Gnd 0.32fF
C11 w_26_37# Gnd 1.12fF
.ends

* Top level circuit pg_gen_optimized_unrouted

Xinv_cmos_3 nand_cmos_3/Y inv_cmos_3/w_0_0# inv_cmos_3/gnd inv_cmos_3/vdd G0 inv_cmos
Xnand_cmos_1 inv_cmos_1/w_0_0# nand_cmos_1/a_7_n61# nand_cmos_1/Y B2 inv_cmos_1/vdd
+ A2 nand_cmos
Xnand_cmos_0 inv_cmos_0/w_0_0# nand_cmos_0/a_7_n61# nand_cmos_0/Y B3 inv_cmos_0/vdd
+ A3 nand_cmos
Xnand_cmos_2 inv_cmos_2/w_0_0# nand_cmos_2/a_7_n61# nand_cmos_2/Y B1 inv_cmos_2/vdd
+ A1 nand_cmos
Xnand_cmos_3 inv_cmos_3/w_0_0# nand_cmos_3/a_7_n61# nand_cmos_3/Y B0 inv_cmos_3/vdd
+ A0 nand_cmos
Xxor_optimized_0 P3 xor_optimized_0/w_26_37# A3 B3 inv_cmos_0/vdd xor_optimized
Xxor_optimized_1 P2 xor_optimized_1/w_26_37# A2 B2 inv_cmos_1/vdd xor_optimized
Xxor_optimized_2 P1 xor_optimized_2/w_26_37# A1 B1 inv_cmos_2/vdd xor_optimized
Xxor_optimized_3 P0 xor_optimized_3/w_26_37# A0 B0 inv_cmos_3/vdd xor_optimized
Xinv_cmos_0 nand_cmos_0/Y inv_cmos_0/w_0_0# inv_cmos_0/gnd inv_cmos_0/vdd G3 inv_cmos
Xinv_cmos_1 nand_cmos_1/Y inv_cmos_1/w_0_0# inv_cmos_1/gnd inv_cmos_1/vdd G2 inv_cmos
Xinv_cmos_2 nand_cmos_2/Y inv_cmos_2/w_0_0# inv_cmos_2/gnd inv_cmos_2/vdd G1 inv_cmos
C0 nand_cmos_0/a_7_n61# A3 0.04fF
C1 inv_cmos_3/w_0_0# inv_cmos_3/vdd 0.01fF
C2 inv_cmos_3/gnd nand_cmos_3/Y 0.30fF
C3 nand_cmos_3/a_7_n61# A0 0.04fF
C4 A2 xor_optimized_1/w_26_37# 0.01fF
C5 nand_cmos_2/a_7_n61# A1 0.04fF
C6 nand_cmos_1/Y inv_cmos_1/vdd 0.55fF
C7 inv_cmos_0/vdd inv_cmos_0/w_0_0# 0.01fF
C8 inv_cmos_1/w_0_0# inv_cmos_1/vdd 0.01fF
C9 nand_cmos_3/Y inv_cmos_3/vdd 0.55fF
C10 A1 inv_cmos_2/vdd 0.16fF
C11 nand_cmos_3/Y A0 0.05fF
C12 nand_cmos_0/Y inv_cmos_0/gnd 0.30fF
C13 inv_cmos_2/gnd nand_cmos_2/Y 0.30fF
C14 inv_cmos_0/vdd A3 0.16fF
C15 B1 G2 0.02fF
C16 nand_cmos_2/Y inv_cmos_2/vdd 0.55fF
C17 G1 B0 0.02fF
C18 B2 G3 0.02fF
C19 xor_optimized_2/w_26_37# A1 0.01fF
C20 nand_cmos_2/Y A1 0.05fF
C21 nand_cmos_1/a_7_n61# A2 0.04fF
C22 inv_cmos_2/w_0_0# inv_cmos_2/vdd 0.01fF
C23 A2 nand_cmos_1/Y 0.05fF
C24 nand_cmos_0/Y inv_cmos_0/w_0_0# -0.00fF
C25 nand_cmos_0/Y inv_cmos_0/vdd 0.55fF
C26 A0 inv_cmos_3/vdd 0.16fF
C27 inv_cmos_2/w_0_0# nand_cmos_2/Y -0.00fF
C28 nand_cmos_0/Y A3 0.05fF
C29 A2 inv_cmos_1/vdd 0.16fF
C30 nand_cmos_3/Y inv_cmos_3/w_0_0# -0.00fF
C31 inv_cmos_1/gnd nand_cmos_1/Y 0.30fF
C32 xor_optimized_3/w_26_37# A0 0.01fF
C33 xor_optimized_0/w_26_37# A3 0.01fF
C34 inv_cmos_3/vdd Gnd -0.31fF
C35 inv_cmos_2/vdd Gnd -0.11fF
C36 inv_cmos_1/vdd Gnd -0.14fF
C37 G1 Gnd 0.02fF
C38 G2 Gnd 0.02fF
C39 G3 Gnd 0.02fF
C40 P0 Gnd 0.02fF
C41 A0 Gnd 0.03fF
C42 B0 Gnd 0.00fF
C43 P1 Gnd 0.02fF
C44 A1 Gnd 0.03fF
C45 B1 Gnd 0.04fF
C46 P2 Gnd 0.02fF
C47 A2 Gnd 0.03fF
C48 B2 Gnd 0.04fF
C49 P3 Gnd 0.02fF
C50 A3 Gnd 0.03fF
C51 inv_cmos_0/vdd Gnd -0.11fF
C52 B3 Gnd 0.04fF
C53 nand_cmos_3/Y Gnd 0.01fF
C54 nand_cmos_2/Y Gnd 0.01fF
C55 nand_cmos_0/Y Gnd 0.01fF
C56 nand_cmos_1/Y Gnd 0.01fF

.tran 1n 640n

.measure tran t_in WHEN v(A3)=0.5*SUPPLY CROSS=1
.measure tran t_out WHEN v(G2)=0.5*SUPPLY CROSS=16
.measure tran t_delay PARAM='t_out-t_in'

.control
    set hcopypscolor = 1
    set color0=beige
    set color1=black
    set color2=blue
    set color3=darkgreen
    set color4=darkred
    set color5=darkviolet
    set color6=darkorange

    run
    plot v(A3)+30 v(A2)+28 v(A1)+26 v(A0)+24 v(B3)+22 v(B2)+20 v(B1)+18 v(B0)+16 v(P3)+14 v(P2)+12 v(P1)+10 v(P0)+8 v(G3)+6 v(G2)+4 v(G1)+2 v(G0)
.endc
