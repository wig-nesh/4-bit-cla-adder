* .include ../../../tech_files/TSMC_180nm.txt
.include ../../xor/optimized/xor_optimized.cir

* .param SUPPLY=1.8
* .param LAMBDA=0.09u
* .param width_N={20*LAMBDA}
* .param width_P={2.5*width_N}
* .param length={2*LAMBDA}
* .global gnd vdd

* VDD vdd gnd SUPPLY
* vinP3 P3 gnd PULSE(0 SUPPLY  320ns 1ps 1ps  320ns   640ns)
* vinP2 P2 gnd PULSE(0 SUPPLY  160ns 1ps 1ps  160ns   320ns)
* vinP1 P1 gnd PULSE(0 SUPPLY   80ns 1ps 1ps   80ns   160ns)
* vinP0 P0 gnd PULSE(0 SUPPLY   40ns 1ps 1ps   40ns    80ns)
* vinC3 C3 gnd PULSE(0 SUPPLY   20ns 1ps 1ps   20ns    40ns)
* vinC2 C2 gnd PULSE(0 SUPPLY   10ns 1ps 1ps   10ns    20ns)
* vinC1 C1 gnd PULSE(0 SUPPLY    5ns 1ps 1ps    5ns    10ns)
* VinC0 C0 gnd PULSE(0 SUPPLY  2.5ns 1ps 1ps  2.5ns     5ns)

.subckt sum_gen_optimized P3 P2 P1 P0 C3 C2 C1 C0 S3 S2 S1 S0
    Xxor3  P3 C3 S3 xor_optimized
    Xxor2  P2 C2 S2 xor_optimized
    Xxor1  P1 C1 S1 xor_optimized
    Xxor0  P0 C0 S0 xor_optimized
.ends

* X1 P3 P2 P1 P0 C3 C2 C1 C0 S3 S2 S1 S0 sum_gen_cmos

* .tran 1n 640n

* .measure tran t_in WHEN v(P0)=0.5*SUPPLY CROSS=1
* .measure tran t_out WHEN v(S3)=0.5*SUPPLY CROSS=2
* .measure tran t_delay PARAM='t_out-t_in'

* .control
*     set hcopypscolor = 1
*     set color0=beige
*     set color1=black
*     set color2=blue
*     set color3=darkgreen
*     set color4=darkred
*     set color5=darkviolet
*     set color6=darkorange

*     run
*     plot v(P3)+22 v(P2)+20 v(P1)+18 v(P0)+16 v(C3)+14 v(C2)+12 v(C1)+10 v(C0)+8 v(S3)+6 v(S2)+4 v(S1)+2 v(S0)
* .endc
